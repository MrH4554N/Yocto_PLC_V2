# Vô hiệu hóa việc copy test suite bằng tar trên WSL2
do_install_ptest() {
    :
}
