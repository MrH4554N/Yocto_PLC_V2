# Bỏ qua quét thư viện động tự động (do gói wheel đã nhúng sẵn thư viện với tên bị mangled)
SKIP_FILEDEPS:${PN} = "1"