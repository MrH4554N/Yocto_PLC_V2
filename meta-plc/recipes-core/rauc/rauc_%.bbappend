FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://system.conf \
            file://development-1.cert"